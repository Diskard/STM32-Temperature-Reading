# Keil uVision project BH-F103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\User;..\User\usart;..\User\exti;..\User\led;..\User\dma_m2uart1;..\User\pwm;..\User\adc;..\User\assist;..\Libraries\USB\CONFIG;..\Libraries\USB\STM32_USB-FS-Device_Driver\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\User\breath;..\User\Beep;..\User\timer;..\User\Temperature;..\User\header
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../User/usart/: bsp_usart.c bsp_usart.h
    ../User/led/: bsp_led.c bsp_led.h
    ../User/exti/: bsp_exti.c bsp_exti.h
    ../User/adc/: bsp_adc.c bsp_adc.h
    ../User/assist/: bsp_assist.c bsp_assist.h
    ../User/breath/: bsp_breathing.c bsp_breathing.h
    ../User/Beep/: bsp_beep.c bsp_beep.h
    ../User/timer/: bsp_basic_timer.c bsp_basic_timer.h
    ../User/Temperature/: bsp_temp_ctrl.c bsp_temp_ctrl.h
    ../User/header/: headers.h
  group DOC
    ../Doc/: 全体目光向我看齐.txt
  group USB_CORE
    ../Libraries/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../Libraries/USB/CONFIG/: hw_config.c hw_config.h platform_config.h usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group SYSTEM
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
